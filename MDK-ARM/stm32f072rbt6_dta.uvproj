# Keil uVision project stm32f072rbt6_dta.uvproj, settings and files
target stm32f072rbt6_dta Configuration (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: stm32f072rbt6_dta Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ..\Inc; ..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0; ..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1f400
  memory RVCT5: ROM 0x801f400 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\stm32f072rbt6_scatter.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash.c stm32f0xx_hal_rtc.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_uart.c stm32f0xx_hal_rcc.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_tim.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_crc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_comp.c
  group Application/User
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c Communication.c rtc.c usart.c gpio.c tim.c crc.c iwdg.c freertos.c rtd_linearization.c adi.c eeprom.c soft_spi.c hd44780.c hd44780_stm32f0xx.c dma.c AD779X.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../Drivers/CMSIS/Lib/: arm_cortexM0l_math.lib
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c list.c timers.c tasks.c croutine.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
